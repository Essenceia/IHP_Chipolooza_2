VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO sg13cmos5l_ocd_Split2000
  CLASS BLOCK ;
  FOREIGN sg13cmos5l_ocd_Split2000 ;
  ORIGIN 0.000 0.000 ;
  SIZE 0.005 BY 0.005 ;
END sg13cmos5l_ocd_Split2000
END LIBRARY

